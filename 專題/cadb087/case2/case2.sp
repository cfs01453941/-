# R=RESISTANCE RPERSQ* L/W
RVDD1_1 M6_200000_229000  M6_2279000_229000 5.1975
RVDD1_2 M5_2279000_419000  M5_2279000_1339000 4.6
RVDD1_3 M6_200000_0  M6_200000_229000 0.5725
RVDD1_4 M6_2279000_229000  M6_2279000_419000 0.475
RVDD1_5 M5_2279000_1339000  M5_2289000_1339000 0.05
RVDD1_6 M5_2289000_1339000  M5_2289000_1349000 0.05
RVDD1_7 M6_2289000_1349000  M6_2292000_1349000 0.0075
RVDD1_8 M6_2279000_419000  M5_2279000_419000 5
RVDD1_9 M5_2289000_1349000  M6_2289000_1349000 5
V_VDD1_1 M6_200000_0 gnd 1
I_VDD1_1 M6_2292000_1349000 gnd 0.005

RVDD2_1 M6_500000_179000  M6_2239000_179000 4.3475
RVDD2_2 M5_2239000_179000  M5_2239000_1539000 6.8
RVDD2_3 M6_500000_0  M6_500000_179000 0.4475
RVDD2_4 M5_2239000_1539000  M5_2289000_1539000 0.25
RVDD2_5 M6_2289000_1539000  M6_2292000_1539000 0.0075
RVDD2_6 M6_2239000_179000  M5_2239000_179000 5
RVDD2_7 M5_2289000_1539000  M6_2289000_1539000 5
V_VDD2_1 M6_500000_0 gnd 1.2
I_VDD2_1 M6_2292000_1539000 gnd 0.002

RVDD3_1 M5_1000000_39000  M5_1000000_1459000 7.1
RVDD3_2 M5_1000000_1459000  M5_771000_1459000 1.145
RVDD3_3 M6_1000000_0  M6_1000000_39000 0.0975
RVDD3_4 M6_771000_1459000  M6_764000_1459000 0.0175
RVDD3_5 M6_1000000_39000  M5_1000000_39000 5
RVDD3_6 M5_771000_1459000  M6_771000_1459000 5
RVDD3_7 M5_1000000_39000  M5_1000000_1149000 5.55
RVDD3_8 M5_1000000_1149000  M5_701000_1149000 1.495
RVDD3_9 M6_1000000_0  M6_1000000_39000 0.0975
RVDD3_10 M6_701000_1149000  M6_697000_1149000 0.01
RVDD3_11 M6_1000000_39000  M5_1000000_39000 5
RVDD3_12 M5_701000_1149000  M6_701000_1149000 5
RVDD3_13 M5_1000000_39000  M5_1000000_509000 2.35
RVDD3_14 M5_1000000_509000  M5_633000_509000 1.835
RVDD3_15 M6_1000000_0  M6_1000000_39000 0.0975
RVDD3_16 M6_1000000_39000  M5_1000000_39000 5
V_VDD3_1 M6_1000000_0 gnd 1
I_VDD3_1 M6_764000_1459000 gnd 0.004
I_VDD3_2 M6_697000_1149000 gnd 0.004
I_VDD3_3 M5_633000_509000 gnd 0.01

RVDD4_1 M4_1499000_39000  M4_3159000_39000 16.6
RVDD4_2 M4_3159000_39000  M4_3159000_531000 4.92
RVDD4_3 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_4 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_5 M6_1499000_39000  M5_1499000_39000 5
RVDD4_6 M5_1499000_39000  M4_1499000_39000 5
RVDD4_7 M4_1499000_39000  M4_3009000_39000 15.1
RVDD4_8 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_9 M4_3009000_39000  M4_3009000_232000 1.93
RVDD4_10 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_11 M6_1499000_39000  M5_1499000_39000 5
RVDD4_12 M5_1499000_39000  M4_1499000_39000 5
RVDD4_13 M4_1499000_39000  M4_2579000_39000 10.8
RVDD4_14 M4_2579000_39000  M4_2579000_1059000 10.2
RVDD4_15 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_16 M4_2579000_1059000  M4_2839000_1059000 2.6
RVDD4_17 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_18 M4_2839000_1059000  M4_2839000_1045000 0.14
RVDD4_19 M6_1499000_39000  M5_1499000_39000 5
RVDD4_20 M5_1499000_39000  M4_1499000_39000 5
RVDD4_21 M4_1499000_39000  M4_2689000_39000 11.9
RVDD4_22 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_23 M4_2689000_39000  M4_2689000_184000 1.45
RVDD4_24 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_25 M6_1499000_39000  M5_1499000_39000 5
RVDD4_26 M5_1499000_39000  M4_1499000_39000 5
RVDD4_27 M4_2319000_39000  M4_2319000_1079000 10.4
RVDD4_28 M4_1499000_39000  M4_2319000_39000 8.2
RVDD4_29 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_30 M4_2319000_1079000  M4_2459000_1079000 1.4
RVDD4_31 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_32 M4_2459000_1079000  M4_2459000_1058000 0.21
RVDD4_33 M6_1499000_39000  M5_1499000_39000 5
RVDD4_34 M5_1499000_39000  M4_1499000_39000 5
RVDD4_35 M4_1499000_39000  M4_2319000_39000 8.2
RVDD4_36 M4_2319000_39000  M4_2319000_669000 6.3
RVDD4_37 M6_1200000_39000  M6_1499000_39000 0.7475
RVDD4_38 M4_2319000_669000  M4_2429000_669000 1.1
RVDD4_39 M6_1200000_0  M6_1200000_39000 0.0975
RVDD4_40 M4_2429000_669000  M4_2429000_651000 0.18
RVDD4_41 M6_1499000_39000  M5_1499000_39000 5
RVDD4_42 M5_1499000_39000  M4_1499000_39000 5
V_VDD4_1 M6_1200000_0 gnd 1.4
I_VDD4_1 M4_3159000_531000 gnd 0.003
I_VDD4_2 M4_3009000_232000 gnd 0.003
I_VDD4_3 M4_2839000_1045000 gnd 0.005
I_VDD4_4 M4_2689000_184000 gnd 0.005
I_VDD4_5 M4_2459000_1058000 gnd 0.004
I_VDD4_6 M4_2429000_651000 gnd 0.004

RVDD5_1 M5_1021000_439000  M5_1021000_1259000 4.1
RVDD5_2 M5_1021000_1259000  M5_1829000_1259000 4.04
RVDD5_3 M5_1500000_439000  M5_1021000_439000 2.395
RVDD5_4 M5_1500000_19000  M5_1500000_439000 2.1
RVDD5_5 M6_1500000_0  M6_1500000_19000 0.0475
RVDD5_6 M6_1839000_1259000  M6_1839000_1245000 0.035
RVDD5_7 M6_1829000_1259000  M6_1839000_1259000 0.025
RVDD5_8 M6_1500000_19000  M5_1500000_19000 5
RVDD5_9 M5_1829000_1259000  M6_1829000_1259000 5
RVDD5_10 M5_1071000_839000  M5_1809000_839000 3.69
RVDD5_11 M5_1500000_439000  M5_1071000_439000 2.145
RVDD5_12 M5_1500000_19000  M5_1500000_439000 2.1
RVDD5_13 M5_1071000_439000  M5_1071000_839000 2
RVDD5_14 M6_1500000_0  M6_1500000_19000 0.0475
RVDD5_15 M6_1819000_839000  M6_1819000_850000 0.0275
RVDD5_16 M6_1809000_839000  M6_1819000_839000 0.025
RVDD5_17 M6_1500000_19000  M5_1500000_19000 5
RVDD5_18 M5_1809000_839000  M6_1809000_839000 5
RVDD5_19 M5_1021000_439000  M5_1021000_1349000 4.55
RVDD5_20 M5_1021000_1349000  M5_1779000_1349000 3.79
RVDD5_21 M5_1500000_439000  M5_1021000_439000 2.395
RVDD5_22 M5_1500000_19000  M5_1500000_439000 2.1
RVDD5_23 M5_1779000_1349000  M5_1779000_1369000 0.1
RVDD5_24 M6_1500000_0  M6_1500000_19000 0.0475
RVDD5_25 M6_1789000_1369000  M6_1789000_1380000 0.0275
RVDD5_26 M6_1779000_1369000  M6_1789000_1369000 0.025
RVDD5_27 M6_1500000_19000  M5_1500000_19000 5
RVDD5_28 M5_1779000_1369000  M6_1779000_1369000 5
RVDD5_29 M3_2209000_249000  M3_2209000_1829000 15.8
RVDD5_30 M3_1689000_249000  M3_2209000_249000 5.2
RVDD5_31 M4_2209000_1829000  M4_1751000_1829000 4.58
RVDD5_32 M5_1500000_19000  M5_1500000_249000 1.15
RVDD5_33 M5_1500000_249000  M5_1689000_249000 0.945
RVDD5_34 M4_1751000_1829000  M4_1751000_1781000 0.48
RVDD5_35 M6_1500000_0  M6_1500000_19000 0.0475
RVDD5_36 M6_1751000_1781000  M6_1769000_1781000 0.045
RVDD5_37 M6_1769000_1781000  M6_1769000_1775000 0.015
RVDD5_38 M6_1500000_19000  M5_1500000_19000 5
RVDD5_39 M5_1689000_249000  M4_1689000_249000 5
RVDD5_40 M4_1689000_249000  M3_1689000_249000 5
RVDD5_41 M3_2209000_1829000  M4_2209000_1829000 5
RVDD5_42 M4_1751000_1781000  M5_1751000_1781000 5
RVDD5_43 M5_1751000_1781000  M6_1751000_1781000 5
RVDD5_44 M5_1500000_19000  M5_1500000_439000 2.1
RVDD5_45 M5_1500000_439000  M5_1311000_439000 0.945
RVDD5_46 M6_1500000_0  M6_1500000_19000 0.0475
RVDD5_47 M6_1311000_439000  M6_1311000_445000 0.015
RVDD5_48 M6_1500000_19000  M5_1500000_19000 5
RVDD5_49 M5_1311000_439000  M6_1311000_439000 5
V_VDD5_1 M6_1500000_0 gnd 1
I_VDD5_1 M6_1839000_1245000 gnd 0.005
I_VDD5_2 M6_1819000_850000 gnd 0.005
I_VDD5_3 M6_1789000_1380000 gnd 0.005
I_VDD5_4 M6_1769000_1775000 gnd 0.005
I_VDD5_5 M6_1311000_445000 gnd 0.005

RVDD6_1 M2_2199000_339000  M2_2199000_1309000 9.7
RVDD6_2 M2_2199000_1309000  M2_1631000_1309000 5.68
RVDD6_3 M2_2019000_0  M2_2019000_339000 3.39
RVDD6_4 M2_2019000_339000  M2_2199000_339000 1.8
RVDD6_5 M6_1631000_1309000  M6_1631000_1245000 0.16
RVDD6_6 M6_2000000_0  M6_2019000_0 0.0475
RVDD6_7 M6_2019000_0  M5_2019000_0 5
RVDD6_8 M5_2019000_0  M4_2019000_0 5
RVDD6_9 M4_2019000_0  M3_2019000_0 5
RVDD6_10 M3_2019000_0  M2_2019000_0 5
RVDD6_11 M2_1631000_1309000  M3_1631000_1309000 5
RVDD6_12 M3_1631000_1309000  M4_1631000_1309000 5
RVDD6_13 M4_1631000_1309000  M5_1631000_1309000 5
RVDD6_14 M5_1631000_1309000  M6_1631000_1309000 5
RVDD6_15 M5_2209000_109000  M5_2209000_799000 3.45
RVDD6_16 M6_2209000_799000  M6_1611000_799000 1.495
RVDD6_17 M6_2000000_39000  M6_2209000_39000 0.5225
RVDD6_18 M6_2209000_39000  M6_2209000_109000 0.175
RVDD6_19 M6_1611000_799000  M6_1611000_850000 0.1275
RVDD6_20 M6_2000000_0  M6_2000000_39000 0.0975
RVDD6_21 M6_2209000_109000  M5_2209000_109000 5
RVDD6_22 M5_2209000_799000  M6_2209000_799000 5
RVDD6_23 M5_2209000_109000  M5_2209000_1349000 6.2
RVDD6_24 M4_2091000_1349000  M4_1591000_1349000 5
RVDD6_25 M6_2000000_39000  M6_2209000_39000 0.5225
RVDD6_26 M5_2209000_1349000  M5_2091000_1349000 0.59
RVDD6_27 M6_2209000_39000  M6_2209000_109000 0.175
RVDD6_28 M6_2000000_0  M6_2000000_39000 0.0975
RVDD6_29 M4_1591000_1349000  M4_1591000_1369000 0.2
RVDD6_30 M6_1581000_1369000  M6_1581000_1380000 0.0275
RVDD6_31 M6_1591000_1369000  M6_1581000_1369000 0.025
RVDD6_32 M6_2209000_109000  M5_2209000_109000 5
RVDD6_33 M5_2091000_1349000  M4_2091000_1349000 5
RVDD6_34 M4_1591000_1369000  M5_1591000_1369000 5
RVDD6_35 M5_1591000_1369000  M6_1591000_1369000 5
RVDD6_36 M5_2209000_109000  M5_2209000_1839000 8.65
RVDD6_37 M5_2209000_1839000  M5_1561000_1839000 3.24
RVDD6_38 M6_2000000_39000  M6_2209000_39000 0.5225
RVDD6_39 M6_2209000_39000  M6_2209000_109000 0.175
RVDD6_40 M5_1561000_1839000  M5_1561000_1781000 0.29
RVDD6_41 M6_2000000_0  M6_2000000_39000 0.0975
RVDD6_42 M6_1561000_1781000  M6_1561000_1775000 0.015
RVDD6_43 M6_2209000_109000  M5_2209000_109000 5
RVDD6_44 M5_1561000_1781000  M6_1561000_1781000 5
RVDD6_45 M5_1821000_39000  M5_1821000_439000 2
RVDD6_46 M6_1821000_439000  M6_1511000_439000 0.775
RVDD6_47 M5_1991000_39000  M5_1821000_39000 0.85
RVDD6_48 M6_2000000_0  M6_2000000_39000 0.0975
RVDD6_49 M6_2000000_39000  M6_1991000_39000 0.0225
RVDD6_50 M6_1511000_439000  M6_1511000_445000 0.015
RVDD6_51 M6_1991000_39000  M5_1991000_39000 5
RVDD6_52 M5_1821000_439000  M6_1821000_439000 5
V_VDD6_1 M6_2000000_0 gnd 1.6
I_VDD6_1 M6_1631000_1245000 gnd 0.006
I_VDD6_2 M6_1611000_850000 gnd 0.006
I_VDD6_3 M6_1581000_1380000 gnd 0.006
I_VDD6_4 M6_1561000_1775000 gnd 0.006
I_VDD6_5 M6_1511000_445000 gnd 0.006

.tran 1ns 1ns
.end
